# Keil uVision project SWM181.uvprojx, settings and files
target SWM181 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: SWM181 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c include: ..\SWM181_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\SWM181_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\SWM181_StdPeriph_Driver\CSL\SWM181_StdPeriph_Driver;.\Common;.\Driver\uart\inc;.\Driver\timer\inc;.\Driver\eeprom\inc;.\APP\lcd\inc;.\APP\key\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Common
    ./Common/: common.c common.h version.c version.h
  group Driver\uart\inc
    ./Driver/uart/inc/: uart.h
  group Driver\uart\src
    ./Driver/uart/src/: uart.c
  group Driver\timer\inc
    ./Driver/timer/inc/: timer.h
  group Driver\timer\src
    ./Driver/timer/src/: timer.c timer_tbl.c
  group Driver\eeprom\inc
    ./Driver/eeprom/inc/: eeprom.h eeprom_api.h
  group Driver\eeprom\src
    ./Driver/eeprom/src/: eeprom.c
  group APP\lcd\inc
    ./APP/lcd/inc/: lcd_control.h lcd_menu.h lcd_screen_data.h lcd_string_en.h lcd_string_zh.h lcd_draw.h lcd_setup.h lcd_menu_type.h lcd_sub_menu.h
  group APP\lcd\src
    ./APP/lcd/src/: lcd_control.c lcd_menu.c lcd_screen_data.c lcd_string_en.c lcd_string_zh.c lcd_draw.c lcd_setup.c lcd_sub_menu.c lcd_menu_type.c
  group APP\key\inc
    ./APP/key/inc/: key_control.h
  group APP\key\src
    ./APP/key/src/: key_control.c
  group Product_Main
    ./Product_Main/: main.c
  group CSL\CMSIS
    ../SWM181_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM181.c
    ../SWM181_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM181.s
  group CSL\swm181
    ../SWM181_StdPeriph_Driver/CSL/SWM181_StdPeriph_Driver/: SWM181_adc.c SWM181_cache.c SWM181_can.c SWM181_cmp.c SWM181_cordic.c SWM181_div.c SWM181_dma.c SWM181_exti.c SWM181_flash.c SWM181_gpio.c SWM181_i2c.c SWM181_irqmux.c SWM181_port.c SWM181_pwm.c SWM181_sdadc.c SWM181_slcd.c SWM181_sleep.c SWM181_spi.c SWM181_timr.c SWM181_uart.c SWM181_wdt.c SWM181_adc.h SWM181_cache.h SWM181_can.h SWM181_cmp.h SWM181_cordic.h SWM181_div.h SWM181_dma.h SWM181_exti.h SWM181_flash.h SWM181_gpio.h SWM181_i2c.h SWM181_irqmux.h SWM181_pwm.h SWM181_sdadc.h SWM181_slcd.h SWM181_sleep.h SWM181_spi.h SWM181_timr.h SWM181_uart.h SWM181_wdt.h
software components: CMSIS:CORE 4.3.0
